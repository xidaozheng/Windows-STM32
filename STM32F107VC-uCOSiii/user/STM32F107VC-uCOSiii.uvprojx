# Keil uVision project STM32F107VC-uCOSiii.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F107VC-uCOSiii
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL USE_STDPERIPH_DRIVER
  c include: ..\library\inc;..\sys\CoreSupport;..\sys;..\user;.\APP;.\BSP;..\uCos-III\uC-CPU;..\uCos-III\uC-LIB;..\uCos-III\uC-CPU\ARM-Cortex-M3\RealView;..\uCos-III\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\uCos-III\uCOS-III\Source;..\uCos-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\BSP\uCOS-III
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group sys
    ../sys/CoreSupport/: core_cm3.c
    ../sys/: stm32f10x_it.c system_stm32f10x.c
    ../sys/arm/: startup_stm32f10x_cl.s
  group library
    ../library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Doc
    ../Doc/: readme.txt
  group APP
    ./APP/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f10x_conf.h
  group BSP
    ./BSP/: bsp.c bsp.h bsp_led.c
  group uC/CPU
    ../uCos-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../uCos-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../uCos-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../uCos-III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../uCos-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../uCos-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
